# Keil uVision project SnifferDemo.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: snifferdemo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\hal\nrf24l01p;..\..\..\hal\nrf24lu1p;..\..\..\compiler\c51;..\..\..\compiler\common
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: usb_desc_templ.c main.c usb.c STARTUP.A51 system.c mcu.c radio_init.c
  group HAL
    ./: hal_nrf_hw.c hal_nrf_l01.c hal_flash.c
    ../../../hal/nrf24lu1p/: cklf.c cpu.c
